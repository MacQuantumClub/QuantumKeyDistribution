## esp-tsf-time-sync/sdkconfig.defaults
```kconfig
CONFIG_ESP_WIFI_SOFTAP_SUPPORT=n
CONFIG_ESP_WIFI_SSID="Pixel_6085"
CONFIG_ESP_WIFI_PASSWORD="2601195007"
```
